# KOMPAS-3D part (ZARD 150.160.27.P.m3d)

Model tree:
1. Булева операция:1
2. Булева операция:2
3. Булева операция:4
